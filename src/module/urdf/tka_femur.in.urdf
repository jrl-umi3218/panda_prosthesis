Commit message: fix(models): fix tka_femur orientation

File: src/module/urdf/tka_femur.in.urdf (robot description, URDF)
Before this commit: robot tka_femur, 4 links, 3 joints
Joints:
- joint support_to_prosthesis: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0.4
